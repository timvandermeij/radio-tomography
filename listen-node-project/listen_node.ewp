# IAR project listen_node.ewp, settings and files
configuration srf05_cc2530 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530; USB_UART; BUF_SIZE=192
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../libraries/cc-usb-firmware/source/components/utils; ../../libraries/cc-usb-firmware/source/components/targets/interface; ../../libraries/cc-usb-firmware/source/components/targets/srf05_soc; ../../libraries/cc-usb-firmware/source/components/common; ../../libraries/cc-usb-firmware/source/components/common/cc8051; ../../libraries/cc-usb-firmware/source/components/targets/common; ../../libraries/cc-usb-firmware/source/components/radios/cc2530; ../../libraries/multi-spin-2.0/multi-Spin_v2.0/xpand2531
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256.xcl
  group application
    ../../libraries/multi-spin-2.0/multi-Spin_v2.0/listen_node/: main.c
  group hal/common
    ../../libraries/cc-usb-firmware/source/components/common/cc8051/: hal_cc8051.h
    ../../libraries/cc-usb-firmware/source/components/common/: hal_defs.h hal_types.h
    ../../libraries/cc-usb-firmware/source/Components/common/: hal_int.c
  group hal/common/io
    ../../libraries/cc-usb-firmware/source/Components/targets/common/: hal_lcd_srf05.c hal_uart_cc8051.c
  group hal/interface
    ../../libraries/cc-usb-firmware/source/components/targets/interface/: hal_assert.h hal_button.h hal_int.h hal_joystick.h hal_lcd.h hal_led.h hal_mcu.h hal_rf.h hal_timer_32k.h hal_uart.h
  group hal/radio
    ../../libraries/cc-usb-firmware/source/components/radios/cc2530/: clock.h
  group hal/radio/cc2530
    ../../libraries/cc-usb-firmware/source/Components/radios/cc2530/: clock.c hal_mcu.c hal_timer_32k.c
  group hal/srf05_soc
    ../../libraries/cc-usb-firmware/source/Components/targets/srf05_soc/: hal_assert.c hal_board.c hal_button.c hal_joystick.c hal_led.c
    ../../libraries/cc-usb-firmware/source/components/targets/srf05_soc/: hal_board.h
  group utilities
    ../../libraries/cc-usb-firmware/source/Components/utils/: util.h util_buffer.c util_buffer.h util_lcd.c util_lcd.h util_uart.c util_uart.h
  group xpand2531
    ../../libraries/multi-spin-2.0/multi-Spin_v2.0/xpand2531/: flash.c flush_buffers.c leds.c rf.c spin_clock.c timers34.c
