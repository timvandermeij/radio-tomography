# IAR project rf_node.ewp, settings and files
configuration Release (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: NDEBUG; chip=2530; INCLUDE_PA=2591
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\libraries\cc-usb-firmware\source\components\common; ..\..\libraries\cc-usb-firmware\source\components\targets\interface; ..\..\libraries\cc-usb-firmware\source\components\targets\srf05_soc; ..\..\libraries\cc-usb-firmware\source\components\common\cc8051; ..\..\libraries\multi-spin-2.0\multi-Spin_v2.0\xpand2531; ..\..\libraries\cc-usb-firmware\source\components\radios\cc2530
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  A8051.ADefines: chip=2530
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256.xcl
  group application
    ../../libraries/multi-spin-2.0/multi-Spin_v2.0/RF_sensor/: main.c
  group xpand2531
    ../../libraries/multi-spin-2.0/multi-Spin_v2.0/xpand2531/: channels.h flash.c flash.h flush_buffers.c flush_buffers.h leds.c leds.h rf.c rf.h spin_clock.c spin_clock.h spin_multichannel.h timers34.c timers34.h usb_uart.h
