# IAR project listen_node.ewp, settings and files
configuration Release (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2531F256.i51
  ICC8051.CCDefines: NDEBUG; BUF_SIZE=192; USB_UART; chip=2531
  ICC8051.CCDiagSuppress: Pe001,Pa084,Pa082
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\libraries\cc-usb-firmware\source\components\usb\class_cdc; ..\..\libraries\cc-usb-firmware\source\components\usb\library; ..\..\libraries\cc-usb-firmware\source\components\common; ..\..\libraries\cc-usb-firmware\source\components\targets\interface; ..\..\libraries\cc-usb-firmware\source\components\targets\cc2531_dongle; ..\..\libraries\cc-usb-firmware\source\components\utils; ..\..\libraries\multi-spin-2.0\multi-Spin_v2.0\xpand2531; ..\..\libraries\cc-usb-firmware\source\components\radios\cc2530
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  A8051.ADefines: chip=2531
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2531F256.xcl
  group application
    ../../libraries/multi-spin-2.0/multi-Spin_v2.0/listen_node/: main.c
  group hal/common
    ../../libraries/cc-usb-firmware/source/components/common/: hal_int.c
  group hal/common/io
    ../../libraries/cc-usb-firmware/source/components/targets/common/: hal_uart_usb.c
  group hal/radio/cc2530
    ../../libraries/cc-usb-firmware/source/components/radios/cc2530/: clock.c hal_mcu.c
  group hal/rfusb
    ../../libraries/cc-usb-firmware/source/components/targets/cc2531_dongle/: hal_assert.c hal_board.c hal_led.c
  group usb/class_cdc
    ../../libraries/cc-usb-firmware/source/components/usb/class_cdc/: usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_firmware_library_config.c usb_uart.c
  group usb/library
    ../../libraries/cc-usb-firmware/source/components/usb/library/: usb_descriptor_parser.c usb_framework.c usb_standard_requests.c
  group usb/library/cc2531
    ../../libraries/cc-usb-firmware/source/components/usb/library/cc2531/: hal_enter_pm.s51 usb_interrupt.c usb_suspend.c
  group utilities
    ../../libraries/cc-usb-firmware/source/components/utils/: util_buffer.c
  group xpand2531
    ../../libraries/multi-spin-2.0/multi-Spin_v2.0/xpand2531/: channels.h flash.c flash.h flush_buffers.c flush_buffers.h leds.c leds.h rf.c rf.h spin_clock.c spin_clock.h spin_multichannel.h timers34.c timers34.h usb_uart.h
