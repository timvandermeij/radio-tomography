# IAR project rf_sensor.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../libraries/cc-usb-firmware/source/components/utils; ../../libraries/cc-usb-firmware/source/components/targets/interface; ../../libraries/cc-usb-firmware/source/components/targets/srf05_soc; ../../libraries/cc-usb-firmware/source/components/common; ../../libraries/cc-usb-firmware/source/components/common/cc8051; ../../libraries/cc-usb-firmware/source/components/targets/common; ../../libraries/cc-usb-firmware/source/components/radios/cc2530; ../../libraries/multi-spin-2.0/multi-Spin_v2.0/xpand2531
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group application
    ../../libraries/multi-spin-2.0/multi-Spin_v2.0/RF_sensor/: main.c
  group xpand2531
    ../../libraries/multi-spin-2.0/multi-Spin_v2.0/xpand2531/: flash.c flush_buffers.c leds.c rf.c spin_clock.c timers34.c
